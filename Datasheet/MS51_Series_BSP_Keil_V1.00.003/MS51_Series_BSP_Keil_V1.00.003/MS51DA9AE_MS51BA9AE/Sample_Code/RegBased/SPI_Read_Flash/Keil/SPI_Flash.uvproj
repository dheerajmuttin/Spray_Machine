# Keil uVision project SPI_Flash.uvproj, settings and files
target SPI_Flash (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: SPI_Flash +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Include
  group Source
    ../: SPI_Flash.c
  group Common
    ../../../../Library/StdDriver/src/: sys.c uart.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
