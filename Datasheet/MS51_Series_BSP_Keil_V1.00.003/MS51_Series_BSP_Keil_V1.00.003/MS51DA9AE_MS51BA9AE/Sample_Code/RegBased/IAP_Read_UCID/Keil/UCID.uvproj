# Keil uVision project UCID.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51DA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: IAP_Read_UID +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: UCID_check.C
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c IAP.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
