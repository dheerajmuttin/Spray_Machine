# Keil uVision project ADC_Bandgap.uvproj, settings and files
target ADC (MCS-51)
  device: MS51DA9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: ADC_IO +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: ADC_BG_VDD.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
