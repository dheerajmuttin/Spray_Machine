# Keil uVision project shree.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: shree +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Library\Device\Include;.\Library\StdDriver\inc
  group Source Group 1
    ./: STARTUP.A51 main.c
  group Peripheral
    ./Library/StdDriver/src/: PWM.c delay.c sys.c
